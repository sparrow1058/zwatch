# IAR project rf_tx.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC1110F32.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: Library\cc1110\CUL\include; Library\cc1110\HAL\include
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC1110F32.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
configuration CC1110_TDMA_TX (8051, debug)
  as the first configuration, except:
configuration CC1110_TDMA_TX1 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC1110_TDMA_TX; CC1110_TDMA_TX1
  group CUL
    Library/cc1110/CUL/source/: dmaAllocChannel.c dmaFreeChannel.c dmaFromAes.c dmaFromRadio.c dmaInit.c dmaSetUpChannel.c dmaToAes.c dmaToFlash.c dmaToRadio.c dmaToUart0.c radio.c spp.c timer4AdmClear.c timer4AdmInit.c timer4AdmReset.c timer4AdmSet.c
  group HAL
    Library/cc1110/HAL/source/: adcSampleSingle.c aesEncrDecr.c aesLoadKeyOrInitVector.c flashErasePage.s51 flashWritePage.s51 getAdcValue.c getkey.c initRandomGenerator.c putchar.c rfConfig.c rfReceivePacket.c rfSendPacket.c rfSetRadioFrequency.c setTimer1Period.c setTimer2Period.c setTimer34Period.c wait.c
  group src
    src/: main.c myio.h mytypedef.h rf_test.c uart.c
