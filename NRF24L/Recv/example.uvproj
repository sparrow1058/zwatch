# Keil uVision project example.uvproj, settings and files
target example (MCS-51)
  device: R80515 Core Cast, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 MDU_R515
  output: Recv +hex
  c flags: Optimize=8 SizeSpeed=1
  group App
    ./: main.c application.c radio.c system.c
  group HAL
    ./: hal_nrf.c hal_nrf_hw.c
