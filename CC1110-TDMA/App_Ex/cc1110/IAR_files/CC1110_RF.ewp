# IAR project CC1110_RF.ewp, settings and files
configuration CC1110_TDMA_TX2 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC1110F32.i51
  ICC8051.CCDefines: chip=1110; COMPLETE_APPLICATION; CC1110_TDMA_TX; CC1110_TDMA_TX2; CC1110
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\LIBRARY\CC1110\CUL\INCLUDE; ..\..\..\LIBRARY\CC1110\HAL\INCLUDE; ..\..\..\LIBRARY\CC1110\EB\INCLUDE; ..\INCLUDE
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC1110F32.xcl
configuration CC1110_TDMA_RX (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC1110.i51
  ICC8051.CCDefines: chip=1110; COMPLETE_APPLICATION; CC1110_TDMA_RX; CC1110
  ICC8051.CCIncludePath2: ..\..\..\LIBRARY\CC1110\CUL\INCLUDE; ..\..\..\LIBRARY\CC1110\HAL\INCLUDE; ..\..\..\LIBRARY\CC1110\EB\INCLUDE; ..\INCLUDE; ..\WXL
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc1110.xcl
configuration CC1110_TDMA_TX1 (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC1110.i51
  ICC8051.CCDefines: chip=1110; COMPLETE_APPLICATION; CC1110_TDMA_TX; CC1110_TDMA_TX1; CC1110
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc1110.xcl
  group (top)
    ../../../: readme.txt
  group appEx
    ../source/: app_ex_main.c Font.c lcd128_64.c rf_test.c Uart_init.c Uart_TX.C
  group cul
    ../../../Library/cc1110/CUL/source/: dmaAllocChannel.c dmaFreeChannel.c dmaFromAes.c dmaFromRadio.c dmaInit.c dmaSetUpChannel.c dmaToAes.c dmaToFlash.c dmaToRadio.c dmaToUart0.c radio.c spp.c timer4AdmClear.c timer4AdmInit.c timer4AdmReset.c timer4AdmSet.c
  group hal
    ../../../Library/cc1110/HAL/source/: adcSampleSingle.c getAdcValue.c rfConfig.c rfSetRadioFrequency.c setTimer2Period.c setTimer34Period.c wait.c
  group tools
    $EW_DIR$/8051/config/: lnk51ew_cc1110.xcl
  group WXL_LCD
    ../../../../CC1110-CSMA/App_Ex/cc1110/wxl/: font.c timer.c uart.c wxlapp.c
