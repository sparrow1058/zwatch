# IAR project RF_TX.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC1110F32 CC1110F32
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC1110F32.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: lnk0t.xcl
  group (top)
    src/: uart.c
  group src
    src/: hal_cc1110.c hal_cc1110.h main.c mytypedef.h RF_CC1110.c rf_cc1110.h
